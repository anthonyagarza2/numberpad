# Repository anthonyagarza2/numberpad

File README.md:

# numberpad
Custom Numberpad pcb

## KiCad design Numpad.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: D; DIODE
SW1, SW2, SW3, SW4, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15: SW_PUSH; CHERRY_PCB_100H
SW5: SW_PUSH; CHERRY_PCB_200H
SW16, SW17: SW_PUSH; CHERRY_PLATE_200V
U1: ProMicro

Connections:
unnamed: D1.1 (K), SW1.2
unnamed: D1.2 (A), D6.2 (A), D10.2 (A), D15.2 (A), U1.16
unnamed: D2.1 (K), SW2.2
unnamed: D3.1 (K), SW3.2
unnamed: D4.1 (K), SW4.2
unnamed: D5.1 (K), SW5.2
unnamed: D6.1 (K), SW6.2
unnamed: D7.1 (K), SW7.2
unnamed: D8.1 (K), SW8.2
unnamed: D9.1 (K), SW9.2
unnamed: D10.1 (K), SW10.2
unnamed: D11.1 (K), SW11.2
unnamed: D2.2 (A), D7.2 (A), D11.2 (A), D16.2 (A), U1.15
unnamed: D12.1 (K), SW12.2
unnamed: D3.2 (A), D8.2 (A), D12.2 (A), U1.10
unnamed: D13.1 (K), SW13.2
unnamed: D4.2 (A), D9.2 (A), D13.2 (A), U1.9
unnamed: D14.1 (K), SW14.2
unnamed: D5.2 (A), D14.2 (A), D17.2 (A), U1.8
unnamed: D15.1 (K), SW15.2
unnamed: D16.1 (K), SW16.2
unnamed: D17.1 (K), SW17.2
unnamed: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, U1.A3
unnamed: SW6.1, SW7.1, SW8.1, SW9.1, U1.A1
unnamed: SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, U1.A2
unnamed: SW15.1, SW16.1, SW17.1, U1.A0

Board: 2 copper layers, 76.4 x 96.1 mm, 35 parts (1 on the bottom side), 26 nets.

## Commit log

2016-12-01 rotated diodes in the schematic. put the switches in the right places
